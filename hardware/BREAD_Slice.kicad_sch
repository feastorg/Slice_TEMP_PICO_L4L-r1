File: hardware/BREAD_Slice.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: fix: clear erc/drc errors
Connections:
- no-connect marks 3 -> 25
